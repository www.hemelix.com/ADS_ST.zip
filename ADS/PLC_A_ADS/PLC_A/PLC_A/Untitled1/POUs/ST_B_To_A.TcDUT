{attribute 'pack_mode' := '1'}
TYPE ST_B_To_A :
STRUCT
    SequenceNo  : UDINT;
    Running     : BOOL;
    ActualValue : REAL;
    AlarmCode   : INT;
	Hello : STRING ;
END_STRUCT
END_TYPE
