{attribute 'pack_mode' := '1'}
TYPE ST_A_To_B :
STRUCT
    SequenceNo : UDINT;
    StartCmd   : BOOL;
    Setpoint   : REAL;
    Mode       : INT;
	HelloFromA : STRING;
END_STRUCT
END_TYPE
